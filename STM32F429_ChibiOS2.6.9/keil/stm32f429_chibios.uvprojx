# Keil uVision project stm32f429_chibios.uvprojx, settings and files
target ChibiOS2.6.9 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429_chibios +hex
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c include: ..\user;..\boards\ST_STM32F429I_DISCOVERY;..\test;..\os\kernel\include;..\os\ports\common\ARMCMx;..\os\ports\common\ARMCMx\CMSIS\include;..\os\ports\RVCT\ARMCMx;..\os\ports\RVCT\ARMCMx\STM32F4xx;..\os\hal\include;..\os\hal\platforms\STM32;..\os\hal\platforms\STM32\GPIOv2;..\os\hal\platforms\STM32\I2Cv1;..\os\hal\platforms\STM32\OTGv1;..\os\hal\platforms\STM32\RTCv1;..\os\hal\platforms\STM32\SPIv1;..\os\hal\platforms\STM32\TIMv1;..\os\hal\platforms\STM32\USARTv1;..\os\hal\platforms\STM32\USBv1;..\os\hal\platforms\STM32F4xx;..\os\various;..\os\various\devices_lib\accel
  asm misc: --cpreproc
  asm include: ..\user;..\boards\ST_STM32F429I_DISCOVERY;..\os\ports\RVCT\ARMCMx\STM32F4xx
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c chconf.h halconf.h mcuconf.h
    ../os/various/: chprintf.c memstreams.c
  group board
    ../boards/ST_STM32F429I_DISCOVERY/: board.c board.h
  group port
    ../os/ports/RVCT/ARMCMx/: cstartup.s chcoreasm_v7m.s chcore.c chcore_v7m.c chcore.h chcore_v7m.h chtypes.h
    ../os/ports/RVCT/ARMCMx/STM32F4xx/: vectors.s cmparams.h
    ../os/ports/common/ARMCMx/: nvic.c nvic.h
  group kernel
    ../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
    ../os/kernel/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chfiles.h chheap.h chinline.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group hal
    ../os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c mmcsd.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c tm.c uart.c usb.c
  group platform
    ../os/hal/platforms/STM32F4xx/: adc_lld.c ext_lld_isr.c hal_lld.c stm32_dma.c
    ../os/hal/platforms/STM32/GPIOv2/: pal_lld.c pal_lld.h
    ../os/hal/platforms/STM32/I2Cv1/: i2c_lld.h i2c_lld.c
    ../os/hal/platforms/STM32/OTGv1/: usb_lld.c stm32_otg.h usb_lld.h
    ../os/hal/platforms/STM32/RTCv1/: rtc_lld.h rtc_lld.c
    ../os/hal/platforms/STM32/SPIv1/: spi_lld.c
    ../os/hal/platforms/STM32/TIMv1/: gpt_lld.c icu_lld.c pwm_lld.c
    ../os/hal/platforms/STM32/USARTv1/: serial_lld.c uart_lld.c
